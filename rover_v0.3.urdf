Commit message: Update rover_v0.3.urdf

File: rover_v0.3.urdf (robot description, URDF)
Before this commit: robot custom_rover, 11 links, 10 joints
Joints:
- joint chassis_to_camera_top: child  -> front_camera_top
